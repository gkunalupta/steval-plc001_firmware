# IAR project PLCLCD.ewp, settings and files
configuration PLCLCD (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx; USE_BPP=16
  ICCARM.CCIncludePath2: ../Core/Inc; ../Fonts; ../TouchGFX/App; ../TouchGFX/target/generated; ../TouchGFX/target; ../touchgfx/framework/include/touchgfx/hal; ../Drivers/BSP/Components/w25xxx; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include; ../ExtLoader/Includes/Library; ../ExtLoader/Includes/Loader; ../Middlewares/ST/touchgfx/framework/include; ../TouchGFX/generated/fonts/include; ../TouchGFX/generated/gui_generated/include; ../TouchGFX/generated/images/include; ../TouchGFX/generated/texts/include; ../TouchGFX/gui/include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: STSW_PLC001.hex
  ILINK.IlinkOutputFile: PLCLCD.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Core/Src/: IPS4260.c ladder.c PLC_timer_api.c ST_PLC_APP.c
    ../Core/Inc/: ladder.h PLC_timer_api.h ST_PLC_APP.h ST_PLC_timerapi.h
    ./: PLCLCD.ipcf
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Core/Src/: CLT01.c CLT03.c ISO8200.c STEVALPLC.c
    ../Core/Inc/: CLT01.h CLT03.h ISO8200.h main.h
  group Application/User/Core
    ../Core/Src/: CT_I2C.cpp freertos.c gt911.cpp main.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: OSWrappers.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp
  group Drivers/BSP/Components/w25xx
    ../Drivers/BSP/Components/w25xxx/: w25xxx.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_10_4bpp_4.cpp Font_verdana_20_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp
  group TouchGFX/generated/gui_generated
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen10_screen/: Screen10ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen11_screen/: Screen11ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen12_screen/: Screen12ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen13_screen/: Screen13ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen14_screen/: Screen14ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen15_screen/: Screen15ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen1_screen/: Screen1ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen2_screen/: Screen2ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen3_screen/: Screen3ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen5_screen/: Screen5ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen6_screen/: Screen6ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen7_screen/: Screen7ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen8_screen/: Screen8ViewBase.cpp
    ../TouchGFX/generated/gui_generated/src/screen9_screen/: Screen9ViewBase.cpp
  group TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp image_back.cpp image_greenffled.cpp image_greenledoff.cpp image_ladder.cpp image_RGB_Circ.cpp image_st_logo.cpp image_start.cpp image_STEVAL-PLC001.cpp image_stop.cpp
    ../TouchGFX/generated/images/src/__designer/: image_Blue_Check_buttons_Check_mark_active.cpp image_Blue_Check_buttons_Check_mark_normal.cpp image_Blue_Check_buttons_Check_mark_pressed.cpp image_Blue_Check_buttons_Check_Round_mark_active.cpp image_Blue_Check_buttons_Check_Round_mark_pressed.cpp
  group TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group TouchGFX/gui/screen10_screen
    ../TouchGFX/gui/src/screen10_screen/: Screen10Presenter.cpp Screen10View.cpp
  group TouchGFX/gui/screen11_screen
    ../TouchGFX/gui/src/screen11_screen/: Screen11Presenter.cpp Screen11View.cpp
  group TouchGFX/gui/screen12_screen
    ../TouchGFX/gui/src/screen12_screen/: Screen12Presenter.cpp Screen12View.cpp
  group TouchGFX/gui/screen13_screen
    ../TouchGFX/gui/src/screen13_screen/: Screen13Presenter.cpp Screen13View.cpp
  group TouchGFX/gui/screen14_screen
    ../TouchGFX/gui/src/screen14_screen/: Screen14Presenter.cpp Screen14View.cpp
  group TouchGFX/gui/screen15_screen
    ../TouchGFX/gui/src/screen15_screen/: Screen15Presenter.cpp Screen15View.cpp
  group TouchGFX/gui/screen1_screen
    ../TouchGFX/gui/src/screen1_screen/: Screen1Presenter.cpp Screen1View.cpp
  group TouchGFX/gui/screen2_screen
    ../TouchGFX/gui/src/screen2_screen/: Screen2Presenter.cpp Screen2View.cpp
  group TouchGFX/gui/screen3_screen
    ../TouchGFX/gui/src/screen3_screen/: Screen3Presenter.cpp Screen3View.cpp
  group TouchGFX/gui/screen5_screen
    ../TouchGFX/gui/src/screen5_screen/: Screen5Presenter.cpp Screen5View.cpp
  group TouchGFX/gui/screen6_screen
    ../TouchGFX/gui/src/screen6_screen/: Screen6Presenter.cpp Screen6View.cpp
  group TouchGFX/gui/screen7_screen
    ../TouchGFX/gui/src/screen7_screen/: Screen7Presenter.cpp Screen7View.cpp
  group TouchGFX/gui/screen8_screen
    ../TouchGFX/gui/src/screen8_screen/: Screen8Presenter.cpp Screen8View.cpp
  group TouchGFX/gui/screen9_screen
    ../TouchGFX/gui/src/screen9_screen/: Screen9Presenter.cpp Screen9View.cpp
  group TouchGFX/Lib
    ../Middlewares/ST/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core.a
